# Keil uVision project STM32_YFCDZ.uvprojx, settings and files
target YFCDZ (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_YFCDZ +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\HARDWARE\LED;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\OLED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\SYSTEM\timer;..\SYSTEM\adc;..\SYSTEM\flash;..\HARDWARE\MODULES;..\SYSTEM\usart2;..\SYSTEM\usart3;..\SYSTEM\usart2;..\SYSTEM\timer;..\HARDWARE\RELAY;..\Gizwits;..\Utils;..\HARDWARE\DHT11;..\HARDWARE\HW;..\HARDWARE\IR;..\HARDWARE\SGP30;..\HARDWARE\STEPMOTOR
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c main.c main.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: OLED.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/MODULES/: Modules.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/HW/: HW.c
    ../HARDWARE/IR/: IR.c
    ../HARDWARE/SGP30/: sgp30.c
    ../HARDWARE/STEPMOTOR/: stepmotor.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/timer/: TIM2.c TIM3.c timer.c
    ../SYSTEM/adc/: adcx.c
    ../SYSTEM/flash/: Flash.c
    ../SYSTEM/usart3/: usart3.c
    ./: usart2.c
    ../SYSTEM/MYRTC/: MyRTC.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_rtc.c
  group README
    ./: readme.txt
  group Gizwits
    ../Gizwits/: gizwits_product.c gizwits_protocol.c
  group Utils
    ../Utils/: common.c dataPointTools.c ringbuffer.c
